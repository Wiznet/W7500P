# IAR project Random_number_generation.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F756ZG ST STM32F756ZG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: ..\..\..\..\..\Libraries\CMSIS\Include; ..\..\..\..\..\Libraries\CMSIS\Device\WIZnet\W7500\Include; ..\..\..\..\..\Libraries\W7500x_stdPeriph_Driver\inc; ..
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Random_number_generation.bin
  ILINK.IlinkOutputFile: main.out
  ILINK.IlinkIcfFile: ..\IAR\W7500_Flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: c.srec
  ILINK.IlinkOutputFile: c.out
  group CMSIS
    ../../../../../Libraries/CMSIS/Device/WIZnet/W7500/Source/: system_W7500x.c
  group IAR-ARM
    ../../../../../Libraries/CMSIS/Device/WIZnet/W7500/Source/IAR/: startup_W7500.s
  group User
    ../: main.c retarget.c W7500x_it.c
  group W7500_Periph
    ../../../../../Libraries/W7500x_stdPeriph_Driver/src/: W7500x_gpio.c W7500x_rng.c W7500x_uart.c
