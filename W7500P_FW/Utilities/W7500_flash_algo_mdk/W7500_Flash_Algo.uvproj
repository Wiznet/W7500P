# Keil uVision project W7500_Flash_Algo.uvproj, settings and files
target W7500_128 (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: W7500_128 +hex
  AfterMake: cmd.exe /C copy "%L" "..\@L.FLM"
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  c flags: Optim=3
  memory RVCT9: RAM 0x20000000 size 0x20004000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
  group Program Functions
    ./: FlashPrg.c
  group Device Description
    ./: FlashDev.c
