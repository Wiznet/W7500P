# IAR project WZTOE_httpClient.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F756ZG ST STM32F756ZG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: ..\..\..\..\..\Libraries\CMSIS\Include; ..\..\..\..\..\Libraries\CMSIS\Device\WIZnet\W7500\Include; ..\..\..\..\..\Libraries\W7500x_stdPeriph_Driver\inc; ..; ..\..\..\..\..\ioLibrary\Application\loopback; ..\..\..\..\..\ioLibrary\Ethernet; ..\..\..\..\..\ioLibrary\Internet\DHCP; ..\..\..\..\..\ioLibrary\Internet\DNS; ..\..\..\..\..\ioLibrary\Internet\httpServer; ..\..\..\..\..\ioLibrary\MDIO
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: WZTOE_httpClient.bin
  ILINK.IlinkOutputFile: main.out
  ILINK.IlinkIcfFile: ..\IAR\W7500_Flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: c.srec
  ILINK.IlinkOutputFile: c.out
  group Applications
    ../../../../../ioLibrary/Application/loopback/: loopback.c
  group CMSIS
    ../../../../../Libraries/CMSIS/Device/WIZnet/W7500/Source/: system_W7500x.c
  group IAR-ARM
    ../../../../../Libraries/CMSIS/Device/WIZnet/W7500/Source/IAR/: startup_W7500.s
  group ioLibrary
    ../../../../../ioLibrary/Internet/DHCP/: dhcp.c
    ../../../../../ioLibrary/Internet/DNS/: dns.c
    ../../../../../ioLibrary/Ethernet/: socket.c wizchip_conf.c
    ../../../../../ioLibrary/MDIO/: W7500x_miim.c
  group User
    ../: main.c retarget.c W7500x_it.c
  group W7500_Periph
    ../../../../../Libraries/W7500x_stdPeriph_Driver/src/: W7500x_crg.c W7500x_gpio.c W7500x_uart.c W7500x_wztoe.c
